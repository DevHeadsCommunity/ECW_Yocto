FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:beaglev-fire = " \
    file://nfs4.cfg \
"
